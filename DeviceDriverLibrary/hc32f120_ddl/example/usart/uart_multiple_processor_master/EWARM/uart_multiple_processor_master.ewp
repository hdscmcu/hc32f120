# IAR project uart_multiple_processor_master.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: uart_multiple_processor_master.srec
  ILINK.IlinkOutputFile: uart_multiple_processor_master.out
  ILINK.IlinkIcfFile: hc32f120x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32f120.c
    ./: startup_hc32f120.s
  group driver
    ../../../../driver/src/: hc32f120_clk.c hc32f120_gpio.c hc32f120_icg.c hc32f120_interrupts.c hc32f120_usart.c hc32f120_utility.c
  group source
    ../source/: main.c
