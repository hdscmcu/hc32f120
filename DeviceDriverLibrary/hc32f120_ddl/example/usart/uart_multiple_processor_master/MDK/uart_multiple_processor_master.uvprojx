# Keil uVision project uart_multiple_processor_master.uvprojx, settings and files
target uart_multiple_processor_master_Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F120H8TA HDSC
  pack: HDSC.HC32F120.1.0.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(20000000) ESEL ELITTLE
  output: uart_multiple_processor_master
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __DEBUG,HC32F120,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f120.s
    ../../../../mcu/common/: system_hc32f120.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: hc32f120_clk.c hc32f120_gpio.c hc32f120_icg.c hc32f120_interrupts.c hc32f120_usart.c hc32f120_utility.c
  group Readme
    ../: Readme.txt
target uart_multiple_processor_master_Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: HC32F120H8TA HDSC
  pack: HDSC.HC32F120.1.0.0
  cpu: as above
  output: uart_multiple_processor_master +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: HC32F120,USE_DDL_DRIVER
  c misc: --diag_suppress=186,66
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc;
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
software components: CMSIS:CORE 5.0.1
