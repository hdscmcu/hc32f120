# IAR project spi_w25qxx.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG; HC32F120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\w25qxx\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: spi_w25qxx.srec
  ILINK.IlinkOutputFile: spi_w25qxx.out
  ILINK.IlinkIcfFile: hc32f120x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: HC32F120; USE_DDL_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\midware\w25qxx\inc; ..\..\..\..\utility
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group (top)
    ../: Readme.txt
  group common
    ../../../../mcu/common/: system_hc32f120.c
    ./: startup_hc32f120.s
  group driver
    ../../../../driver/src/: hc32f120_spi.c hc32f120_clk.c hc32f120_efm.c hc32f120_gpio.c hc32f120_icg.c hc32f120_utility.c
  group midware/w25qxx
    ../../../../midware/w25qxx/src/: w25qxx.c
  group source
    ../source/: main.c
